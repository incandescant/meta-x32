include udev-new.inc

PR = "r0"

SRC_URI[md5sum] = "9af0a8457cc178d18661a5848f18c4c9"
SRC_URI[sha256sum] = "93222392488a52f8eb79c7d4f6b992d19bd375c79a87ead4b480be1cc25382d7"
