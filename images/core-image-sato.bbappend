IMAGE_INSTALL += "file"
