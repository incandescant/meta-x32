#export ac_cv_header_ncurses_h = "yes"

EXTRA_OECONF = "--without-ncurses"
